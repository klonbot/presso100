# IAR project Backup (2) of RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  group (top)
    ./: buttonHandler.c buttonHandler.h ledHandler.c ledHandler.h main.c mainLogic.c mainLogic.h MyLowLevelPutchar.c outline.h pressure.c pressure.h report.c report.h solenoidHendler.c solenoidHendler.h terminal.c terminal.h
  group Demo files
    ParTest/: ParTest.c
    serial/: serial.c
    ./: spi_flash.c stm32f10x_it.c timertest.c
  group FreeRTOS
    FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/MemMang
    FreeRTOS/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group FreeRTOS/portable
    FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group lib
    lib/: close.c lseek.c remove.c write.c
  group ST Library
    STM32F10xFWLib/src/: cortexm3_macro.s lcd.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group System files
    ./: stm32f10x_vector.c
